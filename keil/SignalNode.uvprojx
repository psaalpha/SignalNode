# Keil uVision project SignalNode.uvprojx, settings and files
target SignalNode_F407_Full (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: SignalNode +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,ARM_MATH_CM4,DISABLEFLOAT16
  c misc: --fpu=FPv4-SP --split_sections
  c include: ..\firmware\core;..\firmware\target;..\firmware\platform;..\vendor\spl\inc;..\vendor\device\Include;..\vendor\cmsis-core\CMSIS\Core\Include;..\vendor\cmsis-dsp\Include;..\vendor\cmsis-dsp\PrivateInclude;..\vendor\freertos\include;..\vendor\freertos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../firmware/core/: sn_dsp.c sn_wire.c sn_bfsk.c sn_modbus.c
    ../firmware/target/: sn_system.c sn_board_spl.c sn_app.c sn_fft_tables.c
    ../firmware/platform/: sn_cmsis_fft.c
  group SPL
    ../vendor/spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FreeRTOS
    ../vendor/freertos/: tasks.c queue.c list.c
    ../vendor/freertos/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS-DSP
    ../vendor/cmsis-dsp/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal2.c
  group Startup
    ../firmware/target/: startup_armcc.s
target SignalNode_F407_BFSK_Lite (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: SignalNode +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,ARM_MATH_CM4,DISABLEFLOAT16,SN_ENABLE_SPECTRUM=0
  c misc: --fpu=FPv4-SP --split_sections
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
